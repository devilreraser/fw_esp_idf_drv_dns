## Kconfig.projbuild
```kconfig
menu "Component drv_dns Configuration"

    config DRV_DNS_USE
        bool "Use drv_dns component"
        default y
        
endmenu
```
